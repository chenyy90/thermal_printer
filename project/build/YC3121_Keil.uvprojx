# Keil uVision project YC3121_Keil.uvprojx, settings and files
target thermal_printer (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: thermal_printer +hex
  AfterMake: fromelf.exe --text -a -c --output=@L_asm.txt "!L"
  c flags: Optim=3 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __USEKEILCOMPILE__
  c include: ..\..\hardware\Librarier\sdk;..\..\hardware\Librarier\core;..\..\hardware;..\middle;..\app
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\hardware\ConfigFiles\MDK\YC3121_keil.sct
  group hardware
    ../../hardware/Librarier/startup/: flash_start.s startup.s
    ../../hardware/Librarier/core/: misc.c system.c
    ../../hardware/Librarier/sdk/: yc_gpio.c yc_exti.c yc_uart.c
    ../../hardware/: hal_log.c hal_print.c
  group middle
    ../middle/: middle_print_list.c middle_print.c middle_mmu.c
  group app
    ../app/: main.c
